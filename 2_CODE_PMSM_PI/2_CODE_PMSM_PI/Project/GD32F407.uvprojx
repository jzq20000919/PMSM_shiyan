# Keil uVision project GD32F407.uvprojx, settings and files
target GD32F407 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F407RE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.4.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32F407 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: __TARGET_FPU_VFP,ARM_MATH_CM4,USE_USB_FS
  c include: ..\Firmware\GD32F4xx_standard_peripheral\Include;..\Firmware\CMSIS\GD\GD32F4xx\Include;..\User;..\Hardware;..\Algorithm;..\DSP\Include;..\Firmware\GD32F4xx_usb_library\device\class\cdc\Include;..\Firmware\GD32F4xx_usb_library\device\core\Include;..\Firmware\GD32F4xx_usb_library\driver\Include;..\Firmware\GD32F4xx_usb_library\ustd\common;..\Firmware\GD32F4xx_usb_library\ustd\class\cdc;..\Firmware\GD32F4xx_usb_library;..\Lcd
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Algorithm
    ../Algorithm/: Algorithm.c Chart.c
    E:/永磁同步电机/1、PMSM_PI/1、PMSM_PI/Algorithm_ert_rtw/: Algorithm_data.c
  group Hardware
    ../Hardware/: PWM.c ADC.c GPIO.c EXTI.c
    ../User/: gd32f4xx_hw.c
  group User
    ../User/: systick.c main.c gd32f4xx_it.c Scope.c
    ../Lcd/: lcd.c lcd_init.c
  group Firmware
    ../Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_gpio.c gd32f4xx_rcu.c gd32f4xx_usart.c gd32f4xx_misc.c gd32f4xx_syscfg.c gd32f4xx_exti.c gd32f4xx_timer.c gd32f4xx_dma.c gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_pmu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_wwdgt.c
  group Start
    ../Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
    ../Firmware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f407_427.s
  group Usb
    ../Firmware/GD32F4xx_usb_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
    ../Firmware/GD32F4xx_usb_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
    ../Firmware/GD32F4xx_usb_library/device/class/cdc/Source/: cdc_acm_core.c
software components: CMSIS:CORE 5.4.0
